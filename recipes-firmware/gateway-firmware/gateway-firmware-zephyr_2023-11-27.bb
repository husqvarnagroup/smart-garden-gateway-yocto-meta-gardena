require gateway-firmware.inc

PR = "${INC_PR}.0"
