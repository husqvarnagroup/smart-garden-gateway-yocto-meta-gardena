include gateway-config-backend_${PV}.bb

DEPENDS += "accessory-server-seluxit"
