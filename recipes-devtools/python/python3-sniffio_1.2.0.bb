HOMEPAGE = "https://github.com/python-trio/sniffio"
SUMMARY = "Sniff out which async library your code is running under"

SECTION = "devel/python"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE.MIT;md5=e62ba5042d5983462ad229f5aec1576c"

SRC_URI[md5sum] = "2d7cc6c3a94d3357d333a4ade4a83de8"
SRC_URI[sha256sum] = "c4666eecec1d3f50960c6bdf61ab7bc350648da6c126e3cf6898d8cd4ddcd3de"

inherit setuptools3 pypi
