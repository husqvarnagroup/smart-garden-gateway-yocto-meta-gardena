HOMEPAGE = "https://pypi.org/project/aiorun"
SUMMARY = "This package provides a run() function as the starting point of your asyncio-based application."

SECTION = "devel/python"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=e3fc50a88d0a364313df4b21ef20c29e"

SRC_URI[md5sum] = "2a6513b5078d1bee0dd9c6b4ca68380b"
SRC_URI[sha256sum] = "bb621493e008cd072a9b19de09a615513be2f48b594ee16ee726da5255fa4267"

inherit setuptools3_legacy pypi
