HOMEPAGE = "https://pypi.org/project/aiorun"
SUMMARY = "This package provides a run() function as the starting point of your asyncio-based application."

SECTION = "devel/python"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=e3fc50a88d0a364313df4b21ef20c29e"

SRC_URI[md5sum] = "c066bc042f86981b8133530ef911b28a"
SRC_URI[sha256sum] = "7b16120b4f1aec478cdedbf3d06d05ce4a95622982a2c03ac67a7ee4da463897"

inherit setuptools3 pypi
