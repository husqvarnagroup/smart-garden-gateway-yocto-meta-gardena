SUMMARY = "Python library providing function decorators for configurable backoff and retry"
HOMEPAGE = "https://github.com/litl/backoff"
AUTHOR = "Bob Green <rgreen@aquent.com>"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=11aa62344867e52ff1061aeb075eaa42"

inherit pypi python_poetry_core

SRC_URI[sha256sum] = "03f829f5bb1923180821643f8753b0502c3b682293992485b0eef2807afa5cba"
