DESCRIPTION = "Library for calculating CRC16"
HOMEPAGE = "https://pypi.org/project/crc16/"
SECTION = "devel/python"
LICENSE = "LGPLv3"
LIC_FILES_CHKSUM = "file://PKG-INFO;md5=ce486fbc20f569d6378ec96af2e0e86f"

PYPI_PACKAGE = "crc16"

inherit pypi setuptools3

SRC_URI[md5sum] = "3cb6a4f5fd10a58c09792e321cc467e5"
SRC_URI[sha256sum] = "c1f86aa0390f4baf07d2631b16b979580eae1d9a973a826ce45353a22ee8d396"
