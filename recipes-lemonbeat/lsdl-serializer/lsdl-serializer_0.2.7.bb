require lsdl-serializer.inc

SRCREV = "456e90869688fd00f71cd8d734f2820a95d149b6"

PR = "${INC_PR}.0"
