require lsdl-serializer.inc

SRCREV = "33574a48b0498a1ef4f5513758b5e115f35acf3a"

PR = "${INC_PR}.0"
