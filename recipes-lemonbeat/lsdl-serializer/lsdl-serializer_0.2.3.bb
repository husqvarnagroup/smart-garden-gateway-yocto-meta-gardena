require lsdl-serializer.inc

SRCREV = "fd3d6e7b60863b93cc423777785fc57382c18cb4"

PR = "${INC_PR}.0"
