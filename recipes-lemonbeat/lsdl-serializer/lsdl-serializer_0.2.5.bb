require lsdl-serializer.inc

SRCREV = "70f7c5c2895108ca2787dd080f2df77b30933c91"

PR = "${INC_PR}.0"
