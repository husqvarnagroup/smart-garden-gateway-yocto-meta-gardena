LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=61c3ee8961575861fa86c7e62bc9f69c"

SRC_URI[md5sum] = "7db3f1b4f1df5a3db017e92fcdcd5c96"
SRC_URI[sha256sum] = "f4e572788786a19bc199aedd7f7bf45b54dfd38d6704b906b0a7fc1ac8b9a58f"

PV = "3.0.0a8"
